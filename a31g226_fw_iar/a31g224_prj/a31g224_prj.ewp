# IAR project a31g224_prj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31G224 ABOV A31G224
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ap; bsp; bsp\cmsis\Include; bsp\cmsis\device\Include; common; common\core; common\hw\include; hw; lib\abov_hal\Include; bsp\cmsis\device
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: a31g224_prj.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\A31G224.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: main.c main.h
  group src/ap
    ap/: ap.c ap.h ap_def.h
  group src/bsp
    bsp/: A31G22x_it.c A31G22x_it.h A31G22x_libcfg.h A31G22x_SystemClock.c bsp.c bsp.h
  group src/bsp/CMSIS/device
    bsp/cmsis/device/: system_A31G22x.c system_A31G22x.h
  group src/bsp/CMSIS/device/include
    bsp/cmsis/device/Include/: A31G22x.h
  group src/bsp/CMSIS/include
    bsp/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group src/bsp/startup
    bsp/startup/: cstartup_A31G22x.s
  group src/common
    common/: def.h
  group src/common/core
    common/core/: qblock.c qblock.h qbuffer.c qbuffer.h
  group src/common/hw/include
    common/hw/include/: button.h buzzer.h cdc.h cli.h data_flash.h fatfs.h flash.h gpio.h i2c.h i2c_sw.h ir_remote.h lcd.h led.h log.h pwm.h relay.h resize.h sd.h spi.h tbutton.h uart.h usb.h
  group src/common/hw/include/touch
    common/hw/include/touch/: gt216l.h gt316l.h
  group src/hw
    hw/: hw.c hw.h hw_def.h
  group src/hw/driver
    hw/driver/: buzzer.c cli.c data_flash.c flash.c gpio.c i2c.c i2c_sw.c ir_remote.c lcd.c log.c pwm.c relay.c tbutton.c uart.c
  group src/hw/driver/touch
    hw/driver/touch/: gt216l.c
  group src/lib/abov_hal/include
    lib/abov_hal/Include/: a31g22x_hal_aa_types.h A31G22x_hal_adc.h A31G22x_hal_assert.h A31G22x_hal_cfmc.h A31G22x_hal_cfmc_SelfWriteErase.h A31G22x_hal_cmp.h A31G22x_hal_crc.h A31G22x_hal_dac.h A31G22x_hal_dfmc.h A31G22x_hal_dmac.h A31G22x_hal_i2c.h A31G22x_hal_lcd.h A31G22x_hal_pcu.h A31G22x_hal_pwr.h A31G22x_hal_scu.h A31G22x_hal_spi.h A31G22x_hal_timer1n.h A31G22x_hal_timer2n.h A31G22x_hal_timer3n.h A31G22x_hal_ts.h A31G22x_hal_uartn.h A31G22x_hal_usart1n.h A31G22x_hal_wdt.h A31G22x_hal_wt.h debug.h debug_cmd.h debug_frmwrk.h
  group src/lib/abov_hal/source
    lib/abov_hal/Source/: A31G22x_hal_adc.c A31G22x_hal_cfmc.c A31G22x_hal_cfmc_SelfWriteErase.c A31G22x_hal_cmp.c A31G22x_hal_crc.c A31G22x_hal_dac.c A31G22x_hal_dfmc.c A31G22x_hal_dmac.c A31G22x_hal_i2c.c A31G22x_hal_lcd.c A31G22x_hal_pcu.c A31G22x_hal_pwr.c A31G22x_hal_scu.c A31G22x_hal_spi.c A31G22x_hal_timer1n.c A31G22x_hal_timer2n.c A31G22x_hal_timer3n.c A31G22x_hal_ts.c A31G22x_hal_uartn.c A31G22x_hal_usart1n.c A31G22x_hal_wdt.c A31G22x_hal_wt.c debug.c debug_cmd.c debug_frmwrk.c
